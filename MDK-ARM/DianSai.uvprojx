# Keil uVision project DianSai.uvprojx, settings and files
target DianSai (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: DianSai +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,STM32_THREAD_SAFE_STRATEGY=4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/SEGGER/RTT;../Middlewares/Third_Party/SEGGER/Config;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../bsp/tim;../bsp/can;../bsp/pwm;../bsp/spi;../bsp/usart;../bsp/gpio;../bsp/iic;../bsp/log;../bsp/dwt;../application/chassis;../application/gimbal;../application/slaver;../application;../module/imu;../module/led;../module/encoder;../module/key;../module/pid;../module/motor;../module/gray;../module/algorithm;../module/oled;../module/stepmotor;../module/wheel;../module/zhangdatou_42;../Drivers/CMSIS/DSP/Include/dsp;../Drivers/CMSIS/DSP/Include
  asm include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s armlib_lock_glue.c
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c can.c dma.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/DSP/Include/dsp/: basic_math_functions.h basic_math_functions_f16.h bayes_functions.h bayes_functions_f16.h complex_math_functions.h complex_math_functions_f16.h controller_functions.h controller_functions_f16.h distance_functions.h distance_functions_f16.h fast_math_functions.h fast_math_functions_f16.h filtering_functions.h filtering_functions_f16.h interpolation_functions.h interpolation_functions_f16.h matrix_functions.h matrix_functions_f16.h none.h quaternion_math_functions.h statistics_functions.h statistics_functions_f16.h support_functions.h support_functions_f16.h svm_defines.h svm_functions.h svm_functions_f16.h transform_functions.h transform_functions_f16.h utils.h
    ../Core/Src/: system_stm32f4xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os.h cmsis_os2.h freertos_mpool.h freertos_os2.h cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group module
    ../module/algorithm/: controller.c controller.h crc8.c crc8.h crc16.c crc16.h kalman_filter.c kalman_filter.h mahony_ahrs.c mahony_ahrs.h QuaternionEKF.c QuaternionEKF.h user_lib.c user_lib.h user_lib_math.h
    ../module/encoder/: encoder.c encoder.h
    ../module/gray/: gray.c gray.h
    ../module/imu/: imu_driver.c imu_driver.h mg354pdh0_driver.c mg354pdh0_driver.h
    ../module/key/: key_driver.c key_driver.h
    ../module/led/: led_driver.c led_driver.h
    ../module/motor/: motor_driver.c motor_driver.h
    ../module/oled/: oled_driver.c oled_driver.h
    ../module/pid/: pid.c pid.h
    ../module/wheel/: wheel_driver.c wheel_driver.h
    ../module/zhangdatou_42/: zhangdatou_42.c zhangdatou_42.h
  group application
    ../application/chassis/: chassis.c chassis.h
    ../application/gimbal/: gimbal.c gimbal.h
    ../application/slaver/: slaver.c slaver.h
    ../application/: robot.c robot.h
  group bsp
    ../bsp/adc/: bsp_adc.c bsp_adc.h
    ../bsp/can/: bsp_can.c bsp_can.h
    ../bsp/dwt/: bsp_dwt.c bsp_dwt.h
    ../bsp/flash/: bsp_flash.c bsp_flash.h
    ../bsp/gpio/: bsp_gpio.c bsp_gpio.h
    ../bsp/iic/: bsp_iic.c bsp_iic.h
    ../bsp/log/: bsp_log.c bsp_log.h
    ../bsp/pwm/: bsp_pwm.c bsp_pwm.h
    ../bsp/spi/: bsp_spi.c bsp_spi.h
    ../bsp/tim/: bsp_tim.c bsp_tim.h
    ../bsp/usart/: bsp_usart.c bsp_usart.h
    ../bsp/usb/: bsp_usb.c bsp_usb.h
    ../bsp/: bsp_init.h bsp_tools.c bsp_tools.h
  group Third Party
    ../Middlewares/Third_Party/SEGGER/RTT/: SEGGER_RTT.c
    ../Drivers/CMSIS/DSP/Source/MatrixFunctions/: arm_mat_add_f32.c arm_mat_init_f32.c arm_mat_inverse_f32.c arm_mat_mult_f32.c arm_mat_sub_f32.c arm_mat_trans_f32.c
software components: CMSIS:CORE 4.3.0
